# Keil uVision project Stm32-ucosii-demo.uvproj, settings and files
target STM32-uCOSII-DEMO (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Stm32-ucosii-demo +hex
  c flags: Optim=1
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,USE_STM3210C_EVAL
  c include: ..\App;..\Bsp;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CM3;..\OS-uCOSII\core;..\OS-uCOSII\port;..\OS-uCOSII\uC-CPU;..\OS-uCOSII\Source;..\Libraries\STM32_USB_OTG_Driver\inc;..\Libraries\STM32_USB_Device_Library\Core\inc;..\Libraries\STM32_USB_Device_Library\Class\hid\inc;.\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32F10x_CM3
    ../Libraries/CM3/: core_cm3.c system_stm32f10x.c core_cm3.h stm32f10x.h system_stm32f10x.h
    ../Libraries/CM3/startup/: startup_stm32f10x_cl.s
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_can.c
  group APP
    ../App/: App.c stm32f10x_it.c app_cfg.h includes.h stm32f10x_conf.h stm32f10x_it.h os_cfg.h usart.c user_def.h PCR_Control.c PCR_Cycle.h build_cfg.h
  group BSP
    ../Bsp/: Bsp.c Bsp.h usb_bsp.c usbd_desc.c usbd_usr.c
  group uCOSII_core
    ../OS-uCOSII/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOSII_port
    ../OS-uCOSII/port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group USB Device
    ../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
    ../Libraries/CM3/: stm32f10x.h
  group USB Driver
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
